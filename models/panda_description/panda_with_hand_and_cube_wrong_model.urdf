Commit message: updated config for task 4 and urdf for panda with the cube

File: models/panda_description/panda_with_hand_and_cube_wrong_model.urdf (robot description, URDF)
Before this commit: robot panda, 15 links, 14 joints
Links:
- link panda_finger_cube: mass 10.0 -> 0.1
